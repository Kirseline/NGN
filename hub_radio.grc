options:
  parameters:
    generate_options: qt_gui
    id: hub_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5170000000.0'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: setup_ch_f
  id: variable
  parameters:
    value: 4.167e6
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class pdu_req_reply(gr.basic_block):
          def __init__(self, initial_free_channels=[1, 2, 3, 4, 5], assignment_cooldown=5.0):
              gr.basic_block.__init__(
                  self,
                  name="HUB_Controller",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              
              self.free_channels = list(initial_free_channels)
              
              # Dizionario per memorizzare assegnazioni attive: {ID_SENSORE: (CANALE, TIMESTAMP)}
              self.active_assignments = {}
              self.cooldown = assignment_cooldown

          def handle_msg(self, msg):
              data_pmt = pmt.cdr(msg)
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  if len(payload_bytes) > 24:
                      try:
                          # Decodifica latin-1 per compatibilità con il range 0-255
                          decoded_str = bytes(payload_bytes[24:]).decode('latin-1').strip()
                          
                          if decoded_str.startswith("REQ"):
                              print(f"[1] HUB ricevuto: {decoded_str}")
                              
                              # Estrazione ID (es: da "REQ_1" estrae "1")
                              parts = decoded_str.split('_')
                              sensor_id = parts[1] if len(parts) > 1 else "0"
                              
                              now = time.time()
                              
                              # LOGICA ANTI-BURN: Se il sensore ha già un canale assegnato recentemente,
                              # riproponiamo lo stesso senza estrarne uno nuovo dalla lista.
                              if sensor_id in self.active_assignments:
                                  assigned_ch, last_time = self.active_assignments[sensor_id]
                                  if (now - last_time) < self.cooldown:
                                      reply_str = f"REQ{assigned_ch}_{sensor_id}"
                                      print(f"[RE-TX] HUB ripropone {reply_str} per ID {sensor_id}")
                                      self._send_reply(reply_str)
                                      return

                              # NUOVA ASSEGNAZIONE
                              if self.free_channels:
                                  assigned_ch = self.free_channels.pop(0)
                                  self.active_assignments[sensor_id] = (assigned_ch, now)
                                  
                                  reply_str = f"REQ{assigned_ch}_{sensor_id}"
                                  print(f"[2] HUB assegnazione: {reply_str}")
                                  self._send_reply(reply_str)
                              else:
                                  print(f"[!] HUB canali occupati (richiesta da ID {sensor_id})")
                                  
                      except Exception as e:
                          print(f"Errore HUB: {e}")

          def _send_reply(self, reply_str):
              """Helper per inviare la PDU di risposta"""
              reply_payload = reply_str.encode('latin-1')
              meta = pmt.make_dict()
              data = pmt.init_u8vector(len(reply_payload), list(reply_payload))
              self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, data))
    assignment_cooldown: '1000'
    initial_free_channels: '[ 3]'
  states: {}
- name: epy_block_1_2_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '3'
    header_len: '24'
  states: {}
- name: epy_block_1_2_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '2'
    header_len: '24'
  states: {}
- name: epy_block_1_2_1_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '1'
    header_len: '24'
  states: {}
- name: epy_block_1_2_1_0_0_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '4'
    header_len: '24'
  states: {}
- name: epy_block_1_2_1_0_0_2_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '5'
    header_len: '24'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: setup_ch_f
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: setup_ch_f
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 10e6, 0.625e6, 0.1e6)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ((1 - 1) * 1.666e6) - 4.166e6
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ((2 - 1) * 1.666e6) - 4.166e6
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 833e3
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2.5e6
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-833e3'
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: ieee802_11_mac_0_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0xff,0xff, 0xff, 0xff, 0xff, 0xff]'
    src_mac: '[0x10, 0x10, 0x10, 0x10, 0x10, 0x10]'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dev_addr: '"serial=31AC98A"'
    gain0: '0.5'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    dev_addr: '"serial=31AC98A"'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: wifi_phy_hier_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0_1
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0_2
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0_2_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}

connections:
- [epy_block_1_0, pdu_out, ieee802_11_mac_0_0, app in]
- [freq_xlating_fir_filter_xxx_0_0, '0', uhd_usrp_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0, '0', wifi_phy_hier_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0, '0', wifi_phy_hier_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_0, '0', wifi_phy_hier_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0, '0', wifi_phy_hier_0_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0_0, '0', wifi_phy_hier_0_0_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_1, '0', wifi_phy_hier_0_0_0_1, '0']
- [ieee802_11_mac_0_0, phy out, wifi_phy_hier_0_0, mac_in]
- [rational_resampler_xxx_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [wifi_phy_hier_0_0, '0', rational_resampler_xxx_0_0, '0']
- [wifi_phy_hier_0_0, mac_out, epy_block_1_0, pdu_in]
- [wifi_phy_hier_0_0_0, '0', blocks_null_sink_0, '0']
- [wifi_phy_hier_0_0_0, mac_out, epy_block_1_2_1_0_0_1, pdu_in]
- [wifi_phy_hier_0_0_0_0, '0', blocks_null_sink_0_1, '0']
- [wifi_phy_hier_0_0_0_0, mac_out, epy_block_1_2_1_0_0_0, pdu_in]
- [wifi_phy_hier_0_0_0_1, '0', blocks_null_sink_0_0, '0']
- [wifi_phy_hier_0_0_0_1, mac_out, epy_block_1_2_1_0_0, pdu_in]
- [wifi_phy_hier_0_0_0_2, '0', blocks_null_sink_0_1_0, '0']
- [wifi_phy_hier_0_0_0_2, mac_out, epy_block_1_2_1_0_0_2, pdu_in]
- [wifi_phy_hier_0_0_0_2_0, '0', blocks_null_sink_0_0_0, '0']
- [wifi_phy_hier_0_0_0_2_0, mac_out, epy_block_1_2_1_0_0_2_0, pdu_in]

metadata:
  file_format: 1
