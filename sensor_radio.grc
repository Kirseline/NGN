options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: ID
  id: variable
  parameters:
    value: '0x01'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.45e9
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: setup_ch_f
  id: variable
  parameters:
    value: 4.167e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '400'
    scale: '1'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '50'
    init: '0'
    low: '10'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import threading
      import serial
      import pmt
      import time
      from gnuradio import gr

      class serial_can_dlc_parser(gr.sync_block):
          def __init__(self, port='/dev/ttyACM0', baudrate=115200):
              gr.sync_block.__init__(
                  self, 
                  name="Serial CAN DLC Parser", 
                  in_sig=None, 
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern("out"))
              self.port = port
              self.baudrate = baudrate
              self.ser = None
              self.running = False
              self.packet_buffer = bytearray()
              
              self.START_BYTE = 0x24
              self.TERMINATOR = 0x0A

          def start(self):
              try:
                  self.ser = serial.Serial(self.port, self.baudrate, timeout=0)
                  self.running = True
                  self.thread = threading.Thread(target=self.run_loop, daemon=True)
                  self.thread.start()
                  print(f"[#] Parser Seriale CAN avviato su {self.port}")
                  return True
              except Exception as e:
                  print(f"[!] Errore apertura seriale: {e}")
                  return False

          def run_loop(self):
              while self.running:
                  if self.ser and self.ser.in_waiting > 0:
                      self.packet_buffer.extend(self.ser.read(self.ser.in_waiting))
                      
                      while len(self.packet_buffer) >= 5: 
                          if self.packet_buffer[0] != self.START_BYTE:
                              self.packet_buffer.pop(0)
                              continue
                          
                          dlc = self.packet_buffer[3]
                          expected_len = 5 + dlc
                          
                          if len(self.packet_buffer) >= expected_len:
                              if self.packet_buffer[expected_len - 1] == self.TERMINATOR:
                                  # Estrazione payload escluso start byte [0] e terminatore [end]
                                  frame = list(self.packet_buffer[1:expected_len - 1])
                                  
                                  msg = pmt.init_u8vector(len(frame), frame)
                                  self.message_port_pub(pmt.intern("out"), msg)
                                  
                                  self.packet_buffer = self.packet_buffer[expected_len:]
                              else:
                                  self.packet_buffer.pop(0)
                          else:
                              break
                  
                  time.sleep(0.001)

          def stop(self):
              self.running = False
              if self.ser: 
                  self.ser.close()
              return True

          def work(self, input_items, output_items):
              return 0
    baudrate: '9600'
    port: '''/dev/ttyACM0'''
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import threading
      import time
      import pmt
      import random
      import numpy as np
      from gnuradio import gr

      class sensor_controller(gr.sync_block):
          def __init__(self, sensor_id=1, max_backoff_ms=500, max_retries=5, retry_delay_ms=2000, max_backoff_attempts=10):
              gr.sync_block.__init__(
                  self, 
                  name='Sensor State Controller', 
                  in_sig=[np.float32], 
                  out_sig=None
              )
              
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("payload_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("freq_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("payload_in"), self.handle_payload)
              
              self.sensor_id = sensor_id
              self.max_backoff_ms = max_backoff_ms
              self.max_retries = max_retries
              self.retry_delay_ms = retry_delay_ms
              self.max_backoff_attempts = max_backoff_attempts
              
              self.settling_time = 0.05
              self.guard_interval = 0.5
              
              self.offsets = [-4.167e6, -2.500e6, -0.833e6, 0.833e6, 2.500e6, 4.167e6]
              self.current_channel = 0
              self.current_state = "REQ"
              self.req_attempts = 0
              self.backoff_attempts = 0
              
              self.channel_is_free = True 
              self.last_sample_time = time.time()
              self.running = False
              self.thread = None

          def start(self):
              self.running = True
              self.thread = threading.Thread(target=self.run_loop)
              self.thread.start()
              return True

          def stop(self):
              self.running = False
              if self.thread is not None:
                  self.thread.join()
              return True

          def work(self, input_items, output_items):
              if len(input_items[0]) > 0:
                  valore_grezzo = input_items[0][-1]
                  self.channel_is_free = (valore_grezzo < 0.5)
                  self.last_sample_time = time.time() 
              return len(input_items[0])

          def handle_payload(self, msg):
              # Fase di negoziazione: blocco trasmissione dati se non in stato SIG
              if self.current_state != "SIG":
                  return

              if pmt.is_u8vector(msg):
                  raw_payload = list(pmt.u8vector_elements(msg))
                  offset = self.offsets[self.current_channel]
                  print(f"[4] SENSORE {self.sensor_id} f {offset} TX raw {raw_payload}")
                  
                  meta = pmt.make_dict()
                  data = pmt.init_u8vector(len(raw_payload), raw_payload)
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, data))

          def handle_pdu(self, msg):
              # Pulizia REQ: ignora risposte HUB se la negoziazione è già conclusa
              if self.current_state != "REQ":
                  return

              data_pmt = pmt.cdr(msg)
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  if len(payload_bytes) > 24:
                      try:
                          decoded_str = bytes(payload_bytes[24:]).decode('latin-1').strip()
                          
                          if decoded_str.startswith("REQ") and f"_{self.sensor_id}" in decoded_str:
                              ch_part = decoded_str.split('_')[0]
                              ch_str = "".join(filter(str.isdigit, ch_part))
                              
                              if ch_str:
                                  ch_index = int(ch_str)
                                  if 0 <= ch_index < len(self.offsets):
                                      current_freq = self.offsets[self.current_channel]
                                      freq_target = self.offsets[ch_index]
                                      
                                      print(f"[2] SENSORE {self.sensor_id} RX VALIDO: {decoded_str}")
                                      print(f"[3] SENSORE {self.sensor_id} SALTO su f-{freq_target}")
                                      
                                      # Transizione di stato atomica
                                      self.current_channel = ch_index
                                      self.current_state = "SIG"
                                      time.sleep(self.guard_interval)
                      except Exception as e:
                          print(f"Errore handle_pdu: {e}")

          def run_loop(self):
              while self.running:
                  offset = self.offsets[self.current_channel]
                  msg_freq = pmt.cons(pmt.intern("freq"), pmt.from_double(offset))
                  self.message_port_pub(pmt.intern("freq_out"), msg_freq)
                  
                  time.sleep(self.settling_time)

                  if (time.time() - self.last_sample_time) > 0.1:
                      self.channel_is_free = True

                  if self.current_state == "REQ":
                      if self.req_attempts >= self.max_retries:
                          print(f"[!] SENSORE {self.sensor_id} f {offset} ERRORE - REQ max")
                          self.current_state = "ERROR"
                          continue

                      if self.channel_is_free:
                          self.req_attempts += 1
                          self.backoff_attempts = 0 
                          print(f"[1] SENSORE {self.sensor_id} f {offset} CCA libero - TX REQ {self.req_attempts}/{self.max_retries}")
                          
                          req_msg = f"REQ_{self.sensor_id}"
                          raw_payload = list(req_msg.encode('utf-8'))
                          
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), raw_payload)
                          self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, data))
                          time.sleep(self.retry_delay_ms / 1000.0)
                      else:
                          if self.backoff_attempts >= self.max_backoff_attempts:
                              self.current_state = "ERROR"
                              continue
                          self.backoff_attempts += 1
                          backoff = random.uniform(0, self.max_backoff_ms)
                          print(f"[0] SENSORE {self.sensor_id} f {offset} CCA occupato - Backoff {self.backoff_attempts}: {backoff:.0f} ms")
                          time.sleep(backoff / 1000.0)
                  
                  elif self.current_state == "SIG":
                      time.sleep(0.1)
                  elif self.current_state == "ERROR":
                      time.sleep(1.0)
    max_backoff_attempts: '2'
    max_backoff_ms: '50'
    max_retries: '10'
    retry_delay_ms: '1000'
    sensor_id: ID
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-setup_ch_f'
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 10e6, 0.625e6, 0.1e6)
    type: ccc
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0xff,0xff, 0xff, 0xff, 0xff, 0xff]'
    src_mac: '[ID, ID, ID, ID, ID, ID]'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 625e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '2'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '2'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    dev_addr: '"serial=31AC98A"'
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 10e6
    center_freq0: freq
    dev_addr: '"serial=31AC98A"'
    gain0: '0.6'
    gain_type0: normalized
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_1_0_0, '0']
- [epy_block_0, out, epy_block_1_0_0, payload_in]
- [epy_block_1_0_0, freq_out, freq_xlating_fir_filter_xxx_0, freq]
- [epy_block_1_0_0, pdu_out, ieee802_11_mac_0, app in]
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', uhd_usrp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0, '0', wifi_phy_hier_0, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0_0, '0']
- [wifi_phy_hier_0, '0', rational_resampler_xxx_0, '0']
- [wifi_phy_hier_0, mac_out, epy_block_1_0_0, pdu_in]

metadata:
  file_format: 1
