options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: ID
  id: variable
  parameters:
    value: '0x01'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '5890000000'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '128000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: setup_ch_f
  id: variable
  parameters:
    value: 4.167e6
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '400'
    scale: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '5'
    init: '0'
    low: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import threading
      import serial
      import pmt
      import time
      from gnuradio import gr

      class serial_can_dlc_parser(gr.sync_block):
          def __init__(self, port='/dev/ttyACM0', baudrate=115200):
              gr.sync_block.__init__(
                  self, 
                  name="Serial CAN DLC Parser", 
                  in_sig=None, 
                  out_sig=None
              )
              self.message_port_register_out(pmt.intern("out"))
              self.port = port
              self.baudrate = baudrate
              self.ser = None
              self.running = False
              self.packet_buffer = bytearray()
              
              self.START_BYTE = 0x24
              self.TERMINATOR = 0x0A

          def start(self):
              try:
                  self.ser = serial.Serial(self.port, self.baudrate, timeout=0)
                  self.running = True
                  self.thread = threading.Thread(target=self.run_loop, daemon=True)
                  self.thread.start()
                  print(f"[#] Parser Seriale CAN avviato su {self.port}")
                  return True
              except Exception as e:
                  print(f"[!] Errore apertura seriale: {e}")
                  return False

          def run_loop(self):
              while self.running:
                  if self.ser and self.ser.in_waiting > 0:
                      self.packet_buffer.extend(self.ser.read(self.ser.in_waiting))
                      
                      while len(self.packet_buffer) >= 5: 
                          if self.packet_buffer[0] != self.START_BYTE:
                              self.packet_buffer.pop(0)
                              continue
                          
                          dlc = self.packet_buffer[3]
                          expected_len = 5 + dlc
                          
                          if len(self.packet_buffer) >= expected_len:
                              if self.packet_buffer[expected_len - 1] == self.TERMINATOR:
                                  # Estrazione payload escluso start byte [0] e terminatore [end]
                                  frame = list(self.packet_buffer[1:expected_len - 1])
                                  
                                  msg = pmt.init_u8vector(len(frame), frame)
                                  self.message_port_pub(pmt.intern("out"), msg)
                                  
                                  self.packet_buffer = self.packet_buffer[expected_len:]
                              else:
                                  self.packet_buffer.pop(0)
                          else:
                              break
                  
                  time.sleep(0.001)

          def stop(self):
              self.running = False
              if self.ser: 
                  self.ser.close()
              return True

          def work(self, input_items, output_items):
              return 0
    baudrate: '9600'
    port: '''/dev/ttyACM0'''
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class pdu_req_reply(gr.basic_block):
          def __init__(self, initial_free_channels=[1, 2, 3, 4, 5], assignment_cooldown=5.0):
              gr.basic_block.__init__(
                  self,
                  name="HUB_Controller",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_msg)
              
              self.free_channels = list(initial_free_channels)
              
              # Dizionario per memorizzare assegnazioni attive: {ID_SENSORE: (CANALE, TIMESTAMP)}
              self.active_assignments = {}
              self.cooldown = assignment_cooldown

          def handle_msg(self, msg):
              data_pmt = pmt.cdr(msg)
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  if len(payload_bytes) > 24:
                      try:
                          # Decodifica latin-1 per compatibilità con il range 0-255
                          decoded_str = bytes(payload_bytes[24:]).decode('latin-1').strip()
                          
                          if decoded_str.startswith("REQ"):
                              print(f"[1] HUB ricevuto: {decoded_str}")
                              
                              # Estrazione ID (es: da "REQ_1" estrae "1")
                              parts = decoded_str.split('_')
                              sensor_id = parts[1] if len(parts) > 1 else "0"
                              
                              now = time.time()
                              
                              # LOGICA ANTI-BURN: Se il sensore ha già un canale assegnato recentemente,
                              # riproponiamo lo stesso senza estrarne uno nuovo dalla lista.
                              if sensor_id in self.active_assignments:
                                  assigned_ch, last_time = self.active_assignments[sensor_id]
                                  if (now - last_time) < self.cooldown:
                                      reply_str = f"REQ{assigned_ch}_{sensor_id}"
                                      print(f"[RE-TX] HUB ripropone {reply_str} per ID {sensor_id}")
                                      self._send_reply(reply_str)
                                      return

                              # NUOVA ASSEGNAZIONE
                              if self.free_channels:
                                  assigned_ch = self.free_channels.pop(0)
                                  self.active_assignments[sensor_id] = (assigned_ch, now)
                                  
                                  reply_str = f"REQ{assigned_ch}_{sensor_id}"
                                  print(f"[2] HUB assegnazione: {reply_str}")
                                  self._send_reply(reply_str)
                              else:
                                  print(f"[!] HUB canali occupati (richiesta da ID {sensor_id})")
                                  
                      except Exception as e:
                          print(f"Errore HUB: {e}")

          def _send_reply(self, reply_str):
              """Helper per inviare la PDU di risposta"""
              reply_payload = reply_str.encode('latin-1')
              meta = pmt.make_dict()
              data = pmt.init_u8vector(len(reply_payload), list(reply_payload))
              self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, data))
    assignment_cooldown: '1000'
    initial_free_channels: '[ 3]'
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import threading
      import time
      import pmt
      import random
      import numpy as np
      from gnuradio import gr

      class sensor_controller(gr.sync_block):
          def __init__(self, sensor_id=1, max_backoff_ms=500, max_retries=5, retry_delay_ms=2000, max_backoff_attempts=10):
              gr.sync_block.__init__(
                  self, 
                  name='Sensor State Controller', 
                  in_sig=[np.float32], 
                  out_sig=None
              )
              
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_in(pmt.intern("payload_in"))
              self.message_port_register_out(pmt.intern("pdu_out"))
              self.message_port_register_out(pmt.intern("freq_out"))
              
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.set_msg_handler(pmt.intern("payload_in"), self.handle_payload)
              
              self.sensor_id = sensor_id
              self.max_backoff_ms = max_backoff_ms
              self.max_retries = max_retries
              self.retry_delay_ms = retry_delay_ms
              self.max_backoff_attempts = max_backoff_attempts
              
              self.settling_time = 0.05
              self.guard_interval = 0.5
              
              self.offsets = [-4.167e6, -2.500e6, -0.833e6, 0.833e6, 2.500e6, 4.167e6]
              self.current_channel = 0
              self.current_state = "REQ"
              self.req_attempts = 0
              self.backoff_attempts = 0
              
              self.channel_is_free = True 
              self.last_sample_time = time.time()
              self.running = False
              self.thread = None

          def start(self):
              self.running = True
              self.thread = threading.Thread(target=self.run_loop)
              self.thread.start()
              return True

          def stop(self):
              self.running = False
              if self.thread is not None:
                  self.thread.join()
              return True

          def work(self, input_items, output_items):
              if len(input_items[0]) > 0:
                  valore_grezzo = input_items[0][-1]
                  self.channel_is_free = (valore_grezzo < 0.5)
                  self.last_sample_time = time.time() 
              return len(input_items[0])

          def handle_payload(self, msg):
              # Fase di negoziazione: blocco trasmissione dati se non in stato SIG
              if self.current_state != "SIG":
                  return

              if pmt.is_u8vector(msg):
                  raw_payload = list(pmt.u8vector_elements(msg))
                  offset = self.offsets[self.current_channel]
                  print(f"[4] SENSORE {self.sensor_id} f {offset} TX raw {raw_payload}")
                  
                  meta = pmt.make_dict()
                  data = pmt.init_u8vector(len(raw_payload), raw_payload)
                  self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, data))

          def handle_pdu(self, msg):
              # Pulizia REQ: ignora risposte HUB se la negoziazione è già conclusa
              if self.current_state != "REQ":
                  return

              data_pmt = pmt.cdr(msg)
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  if len(payload_bytes) > 24:
                      try:
                          decoded_str = bytes(payload_bytes[24:]).decode('latin-1').strip()
                          
                          if decoded_str.startswith("REQ") and f"_{self.sensor_id}" in decoded_str:
                              ch_part = decoded_str.split('_')[0]
                              ch_str = "".join(filter(str.isdigit, ch_part))
                              
                              if ch_str:
                                  ch_index = int(ch_str)
                                  if 0 <= ch_index < len(self.offsets):
                                      current_freq = self.offsets[self.current_channel]
                                      freq_target = self.offsets[ch_index]
                                      
                                      print(f"[2] SENSORE {self.sensor_id} RX VALIDO: {decoded_str}")
                                      print(f"[3] SENSORE {self.sensor_id} SALTO su f-{freq_target}")
                                      
                                      # Transizione di stato atomica
                                      self.current_channel = ch_index
                                      self.current_state = "SIG"
                                      time.sleep(self.guard_interval)
                      except Exception as e:
                          print(f"Errore handle_pdu: {e}")

          def run_loop(self):
              while self.running:
                  offset = self.offsets[self.current_channel]
                  msg_freq = pmt.cons(pmt.intern("freq"), pmt.from_double(offset))
                  self.message_port_pub(pmt.intern("freq_out"), msg_freq)
                  
                  time.sleep(self.settling_time)

                  if (time.time() - self.last_sample_time) > 0.1:
                      self.channel_is_free = True

                  if self.current_state == "REQ":
                      if self.req_attempts >= self.max_retries:
                          print(f"[!] SENSORE {self.sensor_id} f {offset} ERRORE - REQ max")
                          self.current_state = "ERROR"
                          continue

                      if self.channel_is_free:
                          self.req_attempts += 1
                          self.backoff_attempts = 0 
                          print(f"[1] SENSORE {self.sensor_id} f {offset} CCA libero - TX REQ {self.req_attempts}/{self.max_retries}")
                          
                          req_msg = f"REQ_{self.sensor_id}"
                          raw_payload = list(req_msg.encode('utf-8'))
                          
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), raw_payload)
                          self.message_port_pub(pmt.intern("pdu_out"), pmt.cons(meta, data))
                          time.sleep(self.retry_delay_ms / 1000.0)
                      else:
                          if self.backoff_attempts >= self.max_backoff_attempts:
                              self.current_state = "ERROR"
                              continue
                          self.backoff_attempts += 1
                          backoff = random.uniform(0, self.max_backoff_ms)
                          print(f"[0] SENSORE {self.sensor_id} f {offset} CCA occupato - Backoff {self.backoff_attempts}: {backoff:.0f} ms")
                          time.sleep(backoff / 1000.0)
                  
                  elif self.current_state == "SIG":
                      time.sleep(0.1)
                  elif self.current_state == "ERROR":
                      time.sleep(1.0)
    max_backoff_attempts: '2'
    max_backoff_ms: '50'
    max_retries: '5'
    retry_delay_ms: '1000'
    sensor_id: ID
  states: {}
- name: epy_block_1_2_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '3'
    header_len: '24'
  states: {}
- name: epy_block_1_2_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '2'
    header_len: '24'
  states: {}
- name: epy_block_1_2_1_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '1'
    header_len: '24'
  states: {}
- name: epy_block_1_2_1_0_0_2
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '4'
    header_len: '24'
  states: {}
- name: epy_block_1_2_1_0_0_2_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class pdu_payload_parser(gr.sync_block):
          def __init__(self, header_len=24, channel = 1):
              gr.sync_block.__init__(
                  self,
                  name="PDU Payload Parser",
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern("pdu_in"))
              self.message_port_register_out(pmt.intern("payload_out"))
              self.set_msg_handler(pmt.intern("pdu_in"), self.handle_pdu)
              self.header_len = header_len
              self.channel = channel

          def handle_pdu(self, msg):
              # Estrazione del vettore dati (cdr) dalla PDU ricevuta
              data_pmt = pmt.cdr(msg)
              
              if pmt.is_u8vector(data_pmt):
                  payload_bytes = pmt.u8vector_elements(data_pmt)
                  
                  # Controllo lunghezza: deve contenere almeno l'header (24 byte)
                  if len(payload_bytes) > self.header_len:
                      try:
                          # Parsing logico: isola la parte utile dal byte 24 in poi
                          raw_payload = payload_bytes[self.header_len:]
                          
                          print(f"HUB parser CH{self.channel} raw : {list(raw_payload)}")
                          # Costruzione PDU di uscita (solo payload)
                          meta = pmt.make_dict()
                          data = pmt.init_u8vector(len(raw_payload), list(raw_payload))
                          
                          # Pubblicazione del messaggio sulla porta out
                          self.message_port_pub(pmt.intern("payload_out"), pmt.cons(meta, data))
                              
                      except Exception as e:
                          print(f"errore parser: {e}")
                          pass

          def work(self, input_items, output_items):
              return 0
    channel: '5'
    header_len: '24'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.01'
    minoutbuf: out_buf_size * 10
    pad_front: '500'
    pad_tail: '0'
  states: {}
- name: foo_packet_pad2_0_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.01'
    minoutbuf: out_buf_size * 10
    pad_front: '500'
    pad_tail: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: setup_ch_f
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-setup_ch_f'
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 10e6, 0.625e6, 0.1e6)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: setup_ch_f
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, 10e6, 0.625e6, 0.1e6)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ((1 - 1) * 1.666e6) - 4.166e6
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ((2 - 1) * 1.666e6) - 4.166e6
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 833e3
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2.5e6
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-833e3'
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.root_raised_cosine(10.0, 10e6, 1e6, 0.35, 110)
    type: ccc
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0xff,0xff, 0xff, 0xff, 0xff, 0xff]'
    src_mac: '[ID, ID, ID, ID, ID, ID]'
  states: {}
- name: ieee802_11_mac_0_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0xff,0xff, 0xff, 0xff, 0xff, 0xff]'
    src_mac: '[0x10, 0x10, 0x10, 0x10, 0x10, 0x10]'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 625e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    type: ccc
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0_1
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0_2
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}
- name: wifi_phy_hier_0_0_0_2_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 1.25e6
    chan_est: ieee802_11.LS
    encoding: '0'
    frequency: freq
    minoutbuf: out_buf_size
    sensitivity: '0.56'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_1_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0_0_1, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']
- [channels_channel_model_0_0, '0', freq_xlating_fir_filter_xxx_0_1_0, '0']
- [epy_block_0, out, epy_block_1_0_0, payload_in]
- [epy_block_1_0, pdu_out, ieee802_11_mac_0_0, app in]
- [epy_block_1_0_0, freq_out, freq_xlating_fir_filter_xxx_0, freq]
- [epy_block_1_0_0, pdu_out, ieee802_11_mac_0, app in]
- [foo_packet_pad2_0, '0', rational_resampler_xxx_0, '0']
- [foo_packet_pad2_0_0, '0', rational_resampler_xxx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', channels_channel_model_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', channels_channel_model_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0, '0', wifi_phy_hier_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0, '0', wifi_phy_hier_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0, '0', wifi_phy_hier_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_0, '0', wifi_phy_hier_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0, '0', wifi_phy_hier_0_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_0_0_0, '0', wifi_phy_hier_0_0_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0_0_1, '0', wifi_phy_hier_0_0_0_1, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [ieee802_11_mac_0_0, phy out, wifi_phy_hier_0_0, mac_in]
- [low_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [wifi_phy_hier_0, '0', foo_packet_pad2_0, '0']
- [wifi_phy_hier_0, mac_out, epy_block_1_0_0, pdu_in]
- [wifi_phy_hier_0_0, '0', foo_packet_pad2_0_0, '0']
- [wifi_phy_hier_0_0, mac_out, epy_block_1_0, pdu_in]
- [wifi_phy_hier_0_0_0, '0', blocks_null_sink_0, '0']
- [wifi_phy_hier_0_0_0, mac_out, epy_block_1_2_1_0_0_1, pdu_in]
- [wifi_phy_hier_0_0_0_0, '0', blocks_null_sink_0_1, '0']
- [wifi_phy_hier_0_0_0_0, mac_out, epy_block_1_2_1_0_0_0, pdu_in]
- [wifi_phy_hier_0_0_0_1, '0', blocks_null_sink_0_0, '0']
- [wifi_phy_hier_0_0_0_1, mac_out, epy_block_1_2_1_0_0, pdu_in]
- [wifi_phy_hier_0_0_0_2, '0', blocks_null_sink_0_1_0, '0']
- [wifi_phy_hier_0_0_0_2, mac_out, epy_block_1_2_1_0_0_2, pdu_in]
- [wifi_phy_hier_0_0_0_2_0, '0', blocks_null_sink_0_0_0, '0']
- [wifi_phy_hier_0_0_0_2_0, mac_out, epy_block_1_2_1_0_0_2_0, pdu_in]

metadata:
  file_format: 1
